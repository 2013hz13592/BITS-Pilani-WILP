; PROGRAM TO CONCATENATE TWO STRING FROM MEMORY    
; PRASENJIT DAS
; 2013HT13592
	AREA RESET, CODE, READONLY
	ENTRY
START 
; ASSIGN MEMORY ADDRESS TO REGISTER
      ADR R3,STRING1
	  ADR R4,STRING2
	  LDR R5,=OUTPUT
	  BL SUB1
STOP B STOP
; LOOP TO FETCH FIRST STRING
SUB1
; MOVE ONE BYTE FROM MEMORY TO REGISTER
	LDRB R0,[R3],#1
	CMP R0,#0
; BRANCH TO NEXT STRING WHEN 0x00 IS FOUND
	BEQ SUB2
; ELSE STORE THE CONTENTS OF REGISTER IN THE OUTPUT AREA	
	STRB R0,[R5],#1
	B SUB1
; LOOP TO FETCH SECOND STRING
SUB2
; MOVE ONE BYTE FROM MEMORY TO REGISTER
	LDRB R0,[R4],#1
	CMP R0,#0
; EXIT WHEN 0x00 IS FOUND	
	BEQ AFT
; ELSE STORE THE CONTENTS OF REGISTER IN THE OUTPUT AREA	
	STRB R0,[r5],#1
	B SUB2
AFT 
	MOV R1, #0
	STRB R1,[r5],#1
	MOV PC,LR
STRING1 DCB "HELLO",0
STRING2 DCB "WORLD",0
	AREA RES,DATA,READWRITE
OUTPUT DCB ""
	END